# Keil uVision project usart.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\librarice\CMSIS;..\librarice\STM32F10x_StdPeriph_Driver\inc;..\user;..\user\led;..\user\systick;..\user\usart;..\user\REMOTE;..\user\oled;..\user\spi;..\user\flash;..\user\key_exti
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../librarice/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../librarice/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../librarice/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../user/led/: bsp_led.c
    ../user/: main.c stm32f10x_it.c
    ../user/usart/: bsp_usart.c
    ../user/REMOTE/: remote.c
    ../user/oled/: bsp_oled.c oledfont.c
    ../user/spi/: bsp_spi.c
    ../user/systick/: bsp_delay.c
    ../user/flash/: bsp_flash.c
  group DOC
    ../doc/: readme.txt
